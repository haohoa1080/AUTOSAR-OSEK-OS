# Keil uVision project 02_TaskManagement.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: 02_TaskMangement
  c flags: Optim=2 v6Lang=1 v6LangP=5
  c include: ..\..\OsekLib;..\02_TaskManagement
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group source group1
    ./: 02_TaskManagement.c
    ../../OsekLib/: hook.c counter.c counter.h os.h OsekLib.lib OsTypes.h
    ../../OsekLib/startup/: keilUvisoin_startup.s
    ../02_TaskManagement/: OsCfg.c OsCfg.h
software components: CMSIS:CORE 5.6.0
