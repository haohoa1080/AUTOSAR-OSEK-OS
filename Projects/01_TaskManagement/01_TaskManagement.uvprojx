# Keil uVision project 01_TaskManagement.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: 01_TaskManagement
  c flags: Optim=2 v6Lang=1 v6LangP=5
  c include: ..\..\OsekLib;..\01_TaskManagement
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ../../OsekLib/: counter.c counter.h os.h OsTypes.h hook.c OsekLib.lib
    ../../OsekLib/startup/: keilUvisoin_startup.s
    ./: OsCfg.c OsCfg.h 01_TaskManagement.c
software components: CMSIS:CORE 5.6.0
